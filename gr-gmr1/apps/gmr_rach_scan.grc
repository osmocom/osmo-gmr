<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gmr1_rach_scan</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>filename</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>rach_detect_fft</key>
<param><key>id</key><value>rach_detect_fft_0</value></param>
<param><key>fft_size</key><value>1 &lt;&lt; int(round(math.log(samp_rate / 1e3) / math.log(2)))</value></param>
<param><key>overlap_ratio</key><value>2</value></param>
<param><key>threshold</key><value>8.5</value></param>
<param><key>burst_length</key><value>int(3 * samp_rate * 15e-3)</value></param>
<param><key>burst_offset</key><value>0</value></param>
<param><key>freq_offset</key><value>- (math.pi / 4.0) * (23400.0 / samp_rate)</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>gsmtap_sink</key>
<param><key>id</key><value>gsmtap_sink_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>port</key><value>4729</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/bursts.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>burst_to_tagged_stream</key>
<param><key>id</key><value>burst_to_tagged_stream_0</value></param>
<param><key>max_length</key><value>8192</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>rach_demod</key>
<param><key>id</key><value>rach_demod_0</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>etoa</key><value>0</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>rach_file_sink</key>
<param><key>id</key><value>rach_file_sink_0</value></param>
<param><key>filename</key><value>/tmp/rach.txt</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>rrate</key><value>93600 / samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0, 32 * samp_rate, 17e3, 2e3)</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<connection><source_block_id>rach_detect_fft_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>rach_detect_fft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rach_demod_0</source_block_id><sink_block_id>gsmtap_sink_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>rach_demod_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>burst_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_to_tagged_stream_0</source_block_id><sink_block_id>rach_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rach_demod_0</source_block_id><sink_block_id>rach_file_sink_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
