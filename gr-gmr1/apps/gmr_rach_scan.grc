options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: gmr1_rach_scan
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/bursts.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: filename
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: burst_to_tagged_stream_0
  id: burst_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    max_length: '8192'
  states: {}
- name: filename
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: gsmtap_sink_0
  id: gsmtap_sink
  parameters:
    host: 127.0.0.1
    port: '4729'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 93600 / samp_rate
    taps: firdes.low_pass(1.0, 32 * samp_rate, 15e3, 2e3)
    type: ccf
  states: {}
- name: rach_demod_0
  id: rach_demod
  parameters:
    etoa: '0'
    len_tag_key: packet_len
    sps: '4'
  states: {}
- name: rach_detect_fft_0
  id: rach_detect_fft
  parameters:
    burst_length: int(3 * samp_rate * 15e-3)
    burst_offset: '0'
    len_tag_key: packet_len
    overlap_ratio: '2'
    peak_freq: (math.pi / 4.0) * (23400.0 / samp_rate)
    samp_rate: samp_rate
    threshold: '8.5'
  states: {}
- name: rach_file_sink_0
  id: rach_file_sink
  parameters:
    center_freq: '0'
    filename: /tmp/rach.txt
    invert_freq: 'True'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 4e6
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_float_0, '0']
- [blocks_float_to_complex_0, '0', rach_detect_fft_0, '0']
- [burst_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [burst_to_tagged_stream_0, '0', rach_demod_0, '0']
- [pfb_arb_resampler_xxx_0, '0', burst_to_tagged_stream_0, '0']
- [rach_demod_0, pdus, blocks_message_debug_0, print_pdu]
- [rach_demod_0, pdus, gsmtap_sink_0, pdus]
- [rach_demod_0, pdus, rach_file_sink_0, pdus]
- [rach_detect_fft_0, '0', pfb_arb_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
